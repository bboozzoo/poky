require go-${PV}.inc
require go.inc

BBCLASSEXTEND = "cross"
